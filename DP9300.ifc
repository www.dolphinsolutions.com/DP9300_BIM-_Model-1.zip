Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2023-11-22T13:20:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.11200.0000 - Exporter 18.0.0.412 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 22 13:20:56 2023 * Host: ANDYHOUSE * Database: C:\Users\ANDYHO~1.DOL\AppData\Local\Temp\{827A9EB6-59F7-49E8-99C4-1AFC743C9872}\ifc * Database version: 5507 * Database creation date: Wed Nov 22 13:20:55 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 22 13:20:55 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 22 13:20:55 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201818
In: Level 1
Type - Material: Default
Type - Dimensions - FFL_Offset: 0 mm; XY_Offset: 0 mm; YZ_Offset: 0 mm
Type - Identity Data - Description: Recessed_Horizontal_Baby_Changing_Unit; Manufacturer: DolphinSolutionsLimited; Model: DP9300; OmniClass Number: 23.40.20.21.37; OmniClass Title: Diaper Changing Units; Type Name: Standard; URL: https://www.dolphinsolutions.co.uk/product/dolphin-horizontal-baby-changing-unit-recessed/
Type - Model Properties - AccessibilityPerformance: n/a; AssetIdentifier: n/a; AssetType: Fixed; BarCode: n/a; Category: Pr_40_20_76_06; CodePerformance: n/a; Constituents: n/a; DurationUnit: year; ExpectedLife: n/a; Finish: BrushedSatin-or-PowderCoated; Grade: 1.4301_304; ManufacturerURL: http://www.dolphinsolutions.co.uk/; Material: StainlessSteel; ModelNumber: DP9300; ModelReference: https://www.dolphinsolutions.co.uk/product/dolphin-horizontal-baby-changing-unit-recessed/; NBSDescription: Baby changing units; NBSReference: Pr_40_20_76_06; NominalHeight: 566; NominalLength: 900; ObjectClassification1: 23.40.20.21.37; ObjectClassification2: DiaperChangingUnits; Part Number: DP9300; Shape: Rectangular; Uniclass2015Code: Pr_40_20_76_06; Uniclass2015Title: Baby changing units; WarrantyDurationUnit: year
Type - Other - Category: Specialty Equipment; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - ModelReference: https://www.dolphinsolutions.co.uk/product/dolphin-horizontal-baby-changing-unit-recessed/; Manufacturer: DolphinSolutionsLimited
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.00623 m2; Volume: 0.0529107 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
